# Keil uVision project 温度测控.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 温度测控 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./SRC/: DS18B20.c KEY.c LCD1602.c
    ./: main.c
